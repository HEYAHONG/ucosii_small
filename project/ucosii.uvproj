# Keil uVision project ucosii.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LV52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: ucosii +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ../source/: INCLUDES.H OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.C uCOS_II.H
  group port
    ../port/: GlobalDef.h OS_CPU.H OS_CPU_A.ASM OS_CPU_C.C STARTUP.A51
  group user
    ../user/: OS_CFG.H LCD1602.c TEST.C LCD1602.H DS1302.H KEY.H
